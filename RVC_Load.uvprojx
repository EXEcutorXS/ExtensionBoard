# Keil uVision project RVC_Load.uvprojx, settings and files
target GD32F303CC (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RVC_LoadV3_3_2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --cpp
  c include: .\src;.\src\ADC;.\src\CAN;.\src\Load;.\src\Memory;.\GD32F30x_SPL\Core;.\GD32F30x_SPL\Include
  memory RVCT4: ROM 0x8008000 size 0x1c000
  memory RVCT9: RAM 0x20000000 size 0xbffc
  group Main
    ./src/: core.cpp main.cpp
  group ADC
    ./src/ADC/: ADCmodule.cpp
  group Load
    ./src/Load/: Load.cpp
  group Config
    ./src/Memory/: config.cpp flash_tools.cpp
  group CAN
    ./src/CAN/: can.cpp Can_Messages.cpp
  group SPL
    ./GD32F30x_SPL/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_exti.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c gd32f30x_fmc.c
    ./GD32F30x_SPL/Core/: startup_gd32f30x_hd.s system_gd32f30x.c
